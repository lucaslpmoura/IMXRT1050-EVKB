# IAR project cmsis_lpspi_edma_b2b_transfer_master.ewp, settings and files
configuration sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6A NXP MIMXRT1052xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: SKIP_SYSCLK_INIT; SDRAM_MPU_INIT; DEBUG; CPU_MIMXRT1052DVL6A
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../../../CMSIS/Include; ../../../../../../../devices; ..; ../../../../../../../CMSIS/Driver/Include; ../../../../..; ../../../../../../../devices/MIMXRT1052/drivers; ../../../../../../../devices/MIMXRT1052; ../../../../../../../devices/MIMXRT1052/utilities/io; ../../../../../../../devices/MIMXRT1052/utilities/str; ../../../../../../../devices/MIMXRT1052/utilities/log; ../../../../../../../devices/MIMXRT1052/utilities; ../../../../../../../devices/MIMXRT1052/cmsis_drivers
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: cmsis_lpspi_edma_b2b_transfer_master.out
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_sdram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1052DVL6A
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_ram.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SKIP_SYSCLK_INIT; SDRAM_MPU_INIT; CPU_MIMXRT1052DVL6A
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1052DVL6A
  ICCARM.CCOptLevel: 3
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_ram.icf
  group source
    ../: cmsis_lpspi_edma_b2b_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../devices/MIMXRT1052/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_lpspi.c fsl_lpspi.h fsl_lpspi_edma.h fsl_lpspi_edma.c
    ../../../../../../../devices/MIMXRT1052/cmsis_drivers/: fsl_lpspi_cmsis.h fsl_lpspi_cmsis.c
  group startup
    ../../../../../../../devices/MIMXRT1052/: system_MIMXRT1052.c system_MIMXRT1052.h
    ../../../../../../../devices/MIMXRT1052/iar/: startup_MIMXRT1052.s
  group utilities
    ../../../../../../../devices/MIMXRT1052/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../../devices/MIMXRT1052/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../../devices/MIMXRT1052/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MIMXRT1052/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
