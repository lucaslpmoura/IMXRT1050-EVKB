<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>cmsis_lpspi_edma_b2b_transfer_master</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>cmsis_lpspi_edma_b2b_transfer_master</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>cmsis_lpspi_edma_b2b_transfer_master</project>
        <configuration>Sdram_debug</configuration>
      </member>
      <member>
        <project>cmsis_lpspi_edma_b2b_transfer_master</project>
        <configuration>Sdram_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>cmsis_lpspi_edma_b2b_transfer_master</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>cmsis_lpspi_edma_b2b_transfer_master</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Sdram_debug</name>
      <member>
        <project>cmsis_lpspi_edma_b2b_transfer_master</project>
        <configuration>Sdram_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Sdram_release</name>
      <member>
        <project>cmsis_lpspi_edma_b2b_transfer_master</project>
        <configuration>Sdram_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/cmsis_lpspi_edma_b2b_transfer_master.ewp</path>
  </project>
</workspace>
