<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>lpspi_interrupt</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>lpspi_interrupt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>lpspi_interrupt</project>
        <configuration>Sdram_debug</configuration>
      </member>
      <member>
        <project>lpspi_interrupt</project>
        <configuration>Sdram_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>lpspi_interrupt</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>lpspi_interrupt</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Sdram_debug</name>
      <member>
        <project>lpspi_interrupt</project>
        <configuration>Sdram_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Sdram_release</name>
      <member>
        <project>lpspi_interrupt</project>
        <configuration>Sdram_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/lpspi_interrupt.ewp</path>
  </project>
</workspace>
