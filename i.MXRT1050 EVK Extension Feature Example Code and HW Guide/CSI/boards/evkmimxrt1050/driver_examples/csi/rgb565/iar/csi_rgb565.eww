<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>csi_rgb565</project>
        <configuration>Sdram_debug</configuration>
      </member>
      <member>
        <project>csi_rgb565</project>
        <configuration>Sdram_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Sdram_debug</name>
      <member>
        <project>csi_rgb565</project>
        <configuration>Sdram_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Sdram_release</name>
      <member>
        <project>csi_rgb565</project>
        <configuration>Sdram_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/csi_rgb565.ewp</path>
  </project>
</workspace>
