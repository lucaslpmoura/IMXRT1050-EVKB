# IAR project csi_ccir656.ewp, settings and files
configuration sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6A NXP MIMXRT1052xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: SKIP_SYSCLK_INIT; SDRAM_MPU_INIT; DEBUG; CPU_MIMXRT1052DVL6A
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../../CMSIS/Include; ../../../../../../devices; ..; ../../../..; ../../../../../../devices/MIMXRT1052/drivers; ../../../../../../devices/MIMXRT1052; ../../../../../../devices/MIMXRT1052/utilities/io; ../../../../../../devices/MIMXRT1052/utilities/str; ../../../../../../devices/MIMXRT1052/utilities/log; ../../../../../../devices/MIMXRT1052/utilities
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: csi_ccir656.out
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_sdram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SKIP_SYSCLK_INIT; SDRAM_MPU_INIT; CPU_MIMXRT1052DVL6A
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../: csi_ccir656.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group video
    ../: fsl_sccb.h fsl_sccb.c fsl_ov7725.h fsl_ov7725.c fsl_csi_camera_adapter.h fsl_csi_camera_adapter.c fsl_camera.h fsl_video_common.h fsl_camera_device.h fsl_camera_receiver.h
  group drivers
    ../../../../../../devices/MIMXRT1052/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_csi.c fsl_csi.h fsl_pxp.c fsl_pxp.h fsl_elcdif.c fsl_elcdif.h fsl_lpi2c.c fsl_lpi2c.h
  group startup
    ../../../../../../devices/MIMXRT1052/: system_MIMXRT1052.c system_MIMXRT1052.h
    ../../../../../../devices/MIMXRT1052/iar/: startup_MIMXRT1052.s
  group utilities
    ../../../../../../devices/MIMXRT1052/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../devices/MIMXRT1052/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../devices/MIMXRT1052/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT1052/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
